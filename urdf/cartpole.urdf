Commit message: edit the cartpole.urdf matching real mass

File: urdf/cartpole.urdf (robot description, URDF)
Before this commit: robot physics, 3 links, 2 joints
Links:
- link pole: mass 10 -> 0.1; geometry collision box size=0.05 0.05 0.5; visual box size=0.05 0.05 0.5
